# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.20.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LV_CONF_INCLUDE_SIMPLE
  c misc: --diag_suppress=174
  c include: .\app;.\lvgl;.\lvgl\lvgl;.\lvgl\lvgl\src\lv_core;.\lvgl\lvgl\src\lv_draw;.\lvgl\lvgl\src\lv_font;.\lvgl\lvgl\src\lv_hal;.\lvgl\lvgl\src\lv_misc;.\lvgl\lvgl\src\lv_objx;.\lvgl\lvgl\src\lv_themes;.\lvgl\lvgl\porting;.\lvgl\lv_examples;.\lvgl\lv_examples\lv_apps\demo;.\FatFs;.\app\bsp;.\app\bsp\IC_COG_TP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ./app/: main.c
  group bsp
    ./app/bsp/: dev_lcd.c dev_rtc.c dev_sdio.c dev_sdram.c dev_spiflash.c dev_systick.c dev_touch.c dev_uart.c
  group lv_core
    ./lvgl/lvgl/src/lv_core/: lv_debug.c lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
  group lv_draw
    ./lvgl/lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
  group lv_font
    ./lvgl/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_12_subpx.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_roboto_28_compressed.c lv_font_unscii_8.c
  group lv_hal
    ./lvgl/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lv_misc
    ./lvgl/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
  group lv_objx
    ./lvgl/lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_cpicker.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
  group lv_themes
    ./lvgl/lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group lvgl_porting
    ./lvgl/lvgl/porting/: lv_port_disp.c lv_port_indev.c
  group Fats
    ./FatFs/: ff.c diskio.c ffunicode.c
  group IC_COG_TP
    ./app/bsp/IC_COG_TP/: LCD_TL021WC02.c LCD_TL040WVS3.c TP_CST826.c TP_FT6336.c TP_GT911.c
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1, Device:Driver:ADC 1.6.0, Device:Driver:CAN 1.6.0, Device:Driver:CRC 1.6.0, Device:Driver:DMA 1.6.0, Device:Driver:EXTI 1.6.0, Device:Driver:FLASH 1.6.0, Device:Driver:GPIO 1.6.0, Device:Driver:I2C 1.6.0, Device:Driver:LCD 1.6.0, Device:Driver:NOR-Flash 1.6.0, Device:Driver:PORT 1.6.0, Device:Driver:PWM 1.6.0, Device:Driver:RTC 1.6.0, Device:Driver:SDIO 1.6.0, Device:Driver:SDRAM 1.6.0, Device:Driver:SPI 1.6.0, Device:Driver:SRAM 1.6.0, Device:Driver:Timer 1.6.0, Device:Driver:UART 1.6.0, Device:Driver:WDT 1.6.0, Device:Startup 1.6.0
